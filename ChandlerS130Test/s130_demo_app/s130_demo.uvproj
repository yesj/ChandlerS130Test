# Keil uVision project s130_demo.uvproj, settings and files
target s130_demo_example (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: S130_demo +hex
  c flags: Optim=1
  c define: NRF51, DEBUG_NRF, PCA10001
  c include: ..\include;.\inc;..\..\framework\builds\build\public\include
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x20000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group main
    ./src/: main.c uart.c rtc1.c system_nrf51.c startup_nrf51.s
